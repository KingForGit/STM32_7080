# Keil uVision project STM32_7080.uvprojx, settings and files
target ec2612_demo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ec2612 +hex
  AfterMake: fromelf --bin ./build/ec2612.axf --output ./ec2612.bin
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\applications;.\drivers;.\Kernel\inc;.\Kernel\portable;.\StmLib\CMSIS;.\StmLib\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x3e800
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Applications
    ./applications/: main.c task_can.c task_uart.c task_monitor.c product.c task_keypad.c
  group Drivers
    ./drivers/: board.c dev_adc.c dev_dac.c dev_uart.c dev_gpio.c dev_fm25clxx.c ops_can.c ops_freq_input.c ops_io_input.c ops_io_output.c ops_pwm_output.c ops_volt_current..c ops_resistan.c ops_soft_time.c ops_storage.c stm32f10x_it.c RTX_Conf_CM.c system_iap.c data_tools.c dev_memory.c can_iap.c dev_beep.c
  group StmLib
    ./StmLib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./StmLib/CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Kernel
    ./Kernel/portable/: HAL_CM3.c SVC_Table.s
    ./Kernel/src/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
